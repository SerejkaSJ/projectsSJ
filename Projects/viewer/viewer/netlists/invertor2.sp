M1 drain1 gate1 source1 sub1 P
M2 drain2 gate1 drain1 sub2 N

M3 drain3 drain1 source3 sub3 P
M4 drain4 drain1 drain3 sub4 N
