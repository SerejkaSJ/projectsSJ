M1 drain1 gate1 source1 sub1 P
M2 drain2 gate1 drain1 sub2 N

M3 drain3 gate3 drain2 sub3 P
M4 drain4 gate3 drain3 sub4 N

M5 drain5 gate5 drain4 sub5 P
M6 drain6 gate5 drain5 sub6 N
