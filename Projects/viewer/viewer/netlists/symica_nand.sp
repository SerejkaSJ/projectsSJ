M0 Y X2 vdd vdd P w=4.2e-007 l=1.8e-007
M1 Y X2 n2_3 n2_3 N w=2.2e-007 l=1.8e-007
M3 Y X1 vdd vdd P w=4.2e-007 l=1.8e-007
M2 n2_3 X1 gnd gnd N w=2.2e-007 l=1.8e-007
