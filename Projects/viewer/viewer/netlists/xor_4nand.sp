MP1_1 AY_1 AX1_1 VDD VDD P
MP2_1 AY_1 AX2_1 VDD VDD P
MN2_1 D2_1 AX2_1 AY_1 GND N
MN1_1 GND AX1_1 D2_1 GND N

MP1_2 AY_2 AY_1 VDD VDD P
MP2_2 AY_2 AX2_1 VDD VDD P
MN2_2 D2_2 AX2_1 AY_2 GND N
MN1_2 GND AY_1 D2_2 GND N

MP1_3 AY_3 AX1_1 VDD VDD P
MP2_3 AY_3 AY_1 VDD VDD P
MN2_3 D2_3 AY_1 AY_3 GND N
MN1_3 GND AX1_1 D2_3 GND N

MP1_4 AY_4 AY_3 VDD VDD P
MP2_4 AY_4 AY_2 VDD VDD P
MN2_4 D2_4 AY_2 AY_4 GND N
MN1_4 GND AY_3 D2_4 GND N
