MP1_1 AY_1 AX1_1 VDD VDD P
MP2_1 AY_1 AX2_1 VDD VDD P
MN2_1 D2_1 AX2_1 AY_1 GND N
MN1_1 GND AX1_1 D2_1 GND N

MP1_2 AX1_1 AX2_1 VDD VDD P
MN1_2 GND AX2_1 AX1_1 GND N

MP1_3 AX2_1 IN1 VDD VDD P
MN1_3 GND IN1 AX2_1 GND N
