M1 drain1 gate1 source1 sub1 P
M2 drain2 gate1 drain1 sub2 N
M3 drain3 gate4 drain2 sub3 N
M4 drain1 gate4 source1 sub4 P

M5 drain5 gate5 source5 sub5 P
M6 drain6 gate5 drain5 sub6 N
M7 source5 gate7 source7 sub7 P
M8 drain6 gate7 drain5 sub8 N

M9 drain9 gate9 source9 sub9 P
M10 drain10 gate9 drain9 sub10 N
