M1 drain1 gate1 source1 sub1 P
M2 drain2 gate1 drain1 sub2 N

M3 drain3 gate3 drain2 sub3 P
M4 drain4 gate3 drain3 sub4 N

M5 drain5 gate5 source5 sub5 P
M6 drain6 gate5 drain5 sub6 N
M7 drain7 gate8 drain6 sub7 N
M8 drain5 gate8 source5 sub8 P

M9 drain9 drain1 source9 sub9 P
M10 drain10 drain1 drain9 sub10 N
M11 drain11 drain3 drain10 sub11 N
M12 drain9 drain3 source9 sub12 P

M13 drain13 drain9 source13 sub13 P
M14 drain14 drain9 drain13 sub14 N
M15 drain15 drain5 drain14 sub15 N
M16 drain13 drain5 source13 sub16 P
